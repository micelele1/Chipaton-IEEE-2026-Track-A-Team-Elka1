v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {name=A1
}
F {}
E {}
C {state_reg.sym} 2590 -2340 0 0 {name=x1}
